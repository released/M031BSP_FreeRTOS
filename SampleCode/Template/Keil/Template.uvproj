# Keil uVision project Template.uvproj, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M032SE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\Library\StdDriver\inc;..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\..\ThirdParty\FreeRTOS;..\..\Template;..\CPU
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c clk.c acmp.c adc.c crc.c ebi.c fmc.c gpio.c i2c.c pdma.c pwm.c spi.c sys.c timer.c usbd.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c
  group User
    ../: main.c
  group FreeRTOS files
    ../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c event_groups.c croutine.c
    ../../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group CPU
    ../CPU/: cpu_utils.c
